# IAR project seusmarter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MK60D10
  ICCARM.CCIncludePath2: K60_Libraries\Core; K60_Libraries\Device; K60_Libraries\Driver\inc; K60_Libraries\Camera\inc; User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: seusmarter.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\MK60xN512_10.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Camera
    K60_Libraries/Camera/src/: DEV_SCCB.c
  group Device
    K60_Libraries/Device/IAR-ARM/: startup_MK60D10.s
    K60_Libraries/Device/: system_MK60D10.c
  group Driver
    K60_Libraries/Driver/src/: adc.c can.c cmp.c common.c cpuidy.c crc.c dac.c dma.c enet.c flash.c flexbus.c ftm.c gpio.c i2c.c i2s.c lptmr.c nfc.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group User
    user/: gui.c img_processing.c init.c isr.c main.c oled.c pid.c pid.h sysinit.c upper_monitor.c varieble.c
